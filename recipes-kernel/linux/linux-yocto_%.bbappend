COMPATIBLE_MACHINE:foobar-machine = "foobar-machine"
